# Repository PubInv/krake

File README.md:

<h1 align="middle">
  Krake™
   </h1>
<h2 align="middle">
 A wireless alarm device purpose-built for life's critical moments
 </h2>
<h1 align="middle">
   
 </h1>
 
The Krake, An Alarm Annunciator designed for easy integration into systems needing to bring to the attention of humans some condition. Can be used by professional system integrators and hobbyists.

This 150 x 180 x 67 mm device has a speaker, a 20x4 character display, five white LEDs. It is a peripheral which can be controlled over a WiFi network using MQTT interface, a wired RS232 interface or customisable audio and visual indications. SPI broker output is implemented separately; SPI alarm input is not enabled in the reviewed ESP32 firmware. 

#### How it works?
1. A condition is detected by an external sensor that relays this information to Krake to trigger and alarm event. Such as a pressure sensor detecting the opening of a gate.
2. The Krake receives the information about the event wirelessly via MQTT over local network or internet. A gate open sensor on a security system would publish a message to the Krake via MQTT or direct RS232 connection
3. Krake displays the alarm message, drives the severity LEDs, and plays configured audio when the alarm is audible and not muted.
4. The user is able to react to the alarm with {acknowledgement, dismissal, shelving or completion}, A mute button allows the user to temporarily mute the audio to prevent alarm fatigue.

## User Manual

A User Manual can be found [here](https://docs.google.com/document/d/1qrhc7Yi6PFmagl4gnvSoc0T4vC_uqu-NLrmWMKFnwA0/edit?usp=sharing).

## Table of Contents

- [Quick Start](#quick-start)
- [About Krake](#about-krake)
- [Example Use Cases](#example-use-cases)
- [Features](#features)
- [Hardware](#hardware)
- [Roadmap (Future Features)](#roadmap-future-features)
- [Contributing](#contributing)
- [Credits & Mentorship](#credits--mentorship)
- [Certifications](#certifications)
- [References & Further Reading](#references--further-reading)

## Quick Start
Once upon a time, we (Robert, Nagham and Lee) had envisioned that upon receiving a Krake the user would practice working with it by using the MQTT web page to publish messages to their device.

Purchasable from https://www.pubinv.org/shop/ 

User manuals & test and assembly procedure can be found in the references and further reading section 

#### LCD UI and local controls

The current firmware includes LCD status pages and rotary-encoder navigation for alarm actions and settings. Available actions include acknowledge, dismiss, shelve, and complete. These actions send GPAP responses; dismiss, shelve, and complete also clear the local displayed alarm.

Settings include volume, alarm repeat interval, mute duration, Wi-Fi status, broker selection, COM configuration, device information, and reset. See the [user manual](https://docs.google.com/document/d/1qrhc7Yi6PFmagl4gnvSoc0T4vC_uqu-NLrmWMKFnwA0/edit?usp=sharing) for operating instructions.

The proposed priority-queue display is described under [Roadmap](#roadmap-future-features).

#### Build your own
To build your own please see instructions for testing and assembly of Krake hardware:
[Krake Test and Assembly Procedure Document](https://github.com/PubInv/krake/wiki/Krake-Test-and-Assembly-Procedure-Document)

## About Krake
The hope was to develop the initial design for a wireless alarm device to alert nearby parties of a particular state. 
About the name, Krake, the inspiration for the invention name is based on a Crake: a bird with a distinctive, slightly alarming cry. We changed the spelling so as to have a unique name and still preserve the humor. 

## Example Use Cases
Care at home: Alert an elderly person living alone to a fall or blood pressure drop — giving family peace of mind from anywhere.

Medical Equipment: For ventilators and critical devices, Krake provides a dedicated alarm channel for life-threatening mechanical failures.

IT Infrastructure: Alert on-site staff instantly when a server overheats, a UPS fails, or network connectivity drops — a physical alarm that doesn't rely on the very infrastructure it's monitoring.

## Features

### Implemented features

The following capabilities are present in the current [GPAD_API firmware](Firmware/GPAD_API/GPAD_API). Availability on an individual device depends on its hardware revision, installed firmware, configuration, audio files, and web filesystem. Source review does not replace testing on the target device.

| Feature | Current implementation |
| --- | --- |
| GPAP alarm messages | Processes severity levels 0–5, optional message IDs and type designators, and alarm text. |
| Audio alarms | DFPlayer-based playback from an SD card, severity-based track selection, adjustable volume, repeat interval, and busy-line checks. MP3 alarm files are documented; WAV playback needs separate verification. |
| LCD and rotary encoder | 20 × 4 character LCD with alarm text, status icons, message paging, local settings, and alarm-action selection. |
| Severity LEDs | Drives the five alarm LEDs according to alarm level. Exact patterns and visibility should be checked on the target device. |
| Mute controls | Physical mute button, timed mute with automatic unmute, indefinite mute, manual unmute, and LCD mute status. |
| Wi-Fi setup and recovery | Setup portal, saved network credentials, multiple stored networks, and reconnection logic. |
| MQTT communication | Configurable broker and topics, alarm subscriptions, response publishing, connection status, and web configuration/monitoring routes. |
| Alarm actions | Acknowledge, dismiss, shelve, and complete actions publish GPAP responses. Dismiss, shelve, and complete clear the local alarm; they do not provide a persistent priority alarm queue or automatic reactivation of shelved alarms. |
| RS-232 communication | UART command handling and saved COM settings, with supported baud rates from 1200 to 115200, 8-N-1 format, and optional RTS/CTS flow control. |
| SPI broker output | Mirrors outgoing MQTT topic/payload pairs over a separate local SPI controller link, including when MQTT is unavailable. This is output, not SPI alarm reception. |
| Firmware updates | ElegantOTA integration for browser-based updates when enabled in the firmware build. Fleet-wide update management is a roadmap item. |
| Device information | Firmware/system information, connection status, and diagnostic output; some diagnostics depend on build settings. |

Implementation references: [main firmware](Firmware/GPAD_API/GPAD_API/GPAD_API.ino), [hardware and LCD logic](Firmware/GPAD_API/GPAD_API/GPAD_HAL.cpp), [local menus](Firmware/GPAD_API/GPAD_API/GPAD_menu.cpp), [audio](Firmware/GPAD_API/GPAD_API/DFPlayer.cpp), and [runtime connectivity/SPI output](Firmware/GPAD_API/README.md#runtime-connectivity-and-spi-broker-mirror).

### Hardware and licensing

- Power connections described for Krake include USB-C, a 2.1 mm center-positive barrel connector, and SPI-interface power jumpers. Follow the hardware revision's wiring and power instructions.
- The Rev. 2 hardware is described with a 3-inch, 10 W, 8-ohm speaker; Rev. 1 uses a smaller speaker.
- Firmware and hardware source files are available in this repository. See the applicable license files and source notices.

### Features requiring verification or further implementation

| Feature or claim | Current status |
| --- | --- |
| SPI alarm input on ESP32 Krake | Legacy GPAD input code exists, but SPI input setup is commented out and input servicing is guarded for GPAD. Do not describe it as enabled on the reviewed ESP32 Krake firmware. |
| HL7 compatibility | GPAP parsing is implemented. Direct HL7 message handling and interoperability have not been established by this review. |
| WAV alarm playback | Needs verification with the audio module, file preparation, and firmware used on the target device. |
| Priority alarm queue | The LCD includes PAQ-style indicators, but the reviewed alarm state stores one current alarm. Queue ordering, retention, and next-alarm selection remain roadmap work. |

## Hardware
| Krake™ rev2 | Krake™ rev1|
| -------- | ------- |
| |  |
| 3 inch 10W Full Range Round 8 ohm Speaker with FR:12-16KHz.| 28mm Speaker|
|dimensions|dimensions|
|functionality?|functionality?|

## Roadmap (Future Features)

These are proposed directions, not capabilities promised for the current firmware or a scheduled release.

- Priority alarm queue: retain multiple alarms, order them by priority, and navigate between pending alarms.
- Extended alarm lifecycle: timed shelving, reactivation, and escalation workflows.
- Enhanced LCD layouts, animations, and icons beyond the existing status pages.
- Bluetooth and BLE alarm forwarding.
- Mesh networking.
- Remote firmware fleet management beyond single-device OTA updates.
- Persistent local event history.
- Expanded GPAP interoperability and defined HL7 integration.
- Power optimization modes.

### Proposed priority-queue LCD layout

This mockup illustrates a future queue view; it is not an exact description of the current screen.

```text
Q:+ NEXT        W B M ⚙
CRIT Pump Failure
ID:123 Temp High
Ack  Dismiss  Shelve
```

## Contributing
[Krake Workflow Contribution Procedure](https://github.com/PubInv/krake/blob/main/WorkflowProcedure.md)

## Credits & Mentorship
The Krake has been developed primarily by volunteer engineer Nagham Kheir, with mentorship and oversight from volunteer Inventional Coach Lee Erickson and a group of volunteers from around the globe. 

[Mentorship and Teamwork: The Story of the Krake](https://www.pubinv.org/2025/03/17/mentorship-and-teamwork-the-story-of-the-krake/)

Nagham Kheir: Invention Coach

Forrest Lee Erickson: Invention Coach

Robert L. Read: Invention Coach

Yehia Shalaby: Public Inventor

Courtney Ludick: Public Inventor

Yukti: Public Inventor

Juhandre Knoetze: Public Inventor

## Certifications

Krake hardware has been certified by the Open Source Hardware Association (OSHWA):
 OSHWA certification listing:
[OSHWA Certification Directory](https://certification.oshwa.org/list.html?utm_source=chatgpt.com)

Certification UID: ``` US002818 ```
 
## References & Further Reading

Brochure: [Copy of Krake Brochure.pdf](https://github.com/user-attachments/files/29981489/Copy.of.Krake.Brochure.pdf)

Logo: 

Krake Repo: https://github.com/PubInv/krake

Wiki: https://github.com/PubInv/krake/wiki

HardwareX Article: [ TBD]

User Manual: [draft user manual](https://docs.google.com/document/d/1qrhc7Yi6PFmagl4gnvSoc0T4vC_uqu-NLrmWMKFnwA0/edit?usp=sharing) 

Developers Manual: [draft developers manual](https://docs.google.com/document/d/150WA6Mb1_SFOBmFc9qBpT5b-MqXb7ejaZbKIxUqaDBY/edit?usp=sharing).

OSHWA certification listing:
[OSHWA Certification Directory](https://certification.oshwa.org/list.html?utm_source=chatgpt.com)

The team behind Krake: [Mentorship and Teamwork: The Story of the Krake](https://www.pubinv.org/2025/03/17/mentorship-and-teamwork-the-story-of-the-krake/)

Krake workflow: [Krake Workflow Contribution Procedure](https://github.com/PubInv/krake/blob/main/WorkflowProcedure.md)

Build your own: [Krake Test and Assembly Procedure Document](https://github.com/PubInv/krake/wiki/Krake-Test-and-Assembly-Procedure-Document)

Global Open Source Quality Assuring System:[Asset History Records Public Invention Krake Rev. 2](https://gosqas.org/record/8CMgkfrS4ufevweKy1QowF)

GPAP:  https://github.com/PubInv/gpap

#### Public Invention

- Github repo: https://github.com/PubInv
- Website: https://www.pubinv.org/
- Products page: https://www.pubinv.org/shop/

## KiCad design PWA_REV2/PWA_REV2.kicad_pcb

File PWA_REV2/README.md:

# Summary
The Krake Rev 2 PWA fixes a major problem with the CH340 USB to UART feature of Rev 1 which was missing a crystal from the PCB and could not work.

## Document Descriptions
for some selected documents in this folder.  
The Rev2 PWA [Krake_Test_and_Assembly_Procedure.md](https://github.com/PubInv/krake/blob/main/PWA_REV2/Krake_Test_and_Assembly_Procedure.md)

## References
Link to issue capturing the order from PCBWay of PWA subassemblies.  
Link to issue capturing the order from other vendors of balance of BOM for PWAs.

Board: 2 copper layers, 137.2 x 83.8 mm, 214 parts (17 on the bottom side), 137 nets.

Parts:
+5esp32: +5esp32; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
C101: 39pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C102, C106, C109, C115, C118, C302, C502, C505, C705: 47uF 16V; CP_Elec_5x5.4
C103, C105, C108, C116, C117, C301, C303, C501, C503, C504, C602, C701, C702, C703, C704, C706, C1100: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D101, D103, D104: Schottky 2A; D_SMB_POLARITY
D105: LED_T1.75_CLEAR_RED; LED_5mm_Radial
D106: RED 0603; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D201, D202, D203, D204, D205: LED_T1.75_CLEAR_WHITE; LED_5mm_Radial
D301, D302, D303, D304: BAT54S; SOT-23
D501: RED 0603; LED_0603_1608Metric
F101, F401: Polyfuse_Small_1A; Fuse_0603_1608Metric
H101, H102, H103, H104: MountingHole_Pad_3.5mm; MountingHole_3.5mm_Pad_Via
J101: Barrel_Jack_Switch_SMT; BarrelJack_CLIFF_FC681465S_SMT_Horizontal
J102, J103, J602: 0.100_2Pin; PinHeader_1x02_P2.54mm_Vertical
J104, J106: Conn_01x14 1mm; PinSocket_1x14_P1.00mm_Vertical
J107: Conn_01x10 1mm; PinSocket_1x10_P1.00mm_Vertical
J401: RJ12_6P6C_HORZ; RJ12_Amphenol_54601
J501: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J601: 1X2P 1.25 mm Header; Molex_PicoBlade_53047-0210_1x02_P1.25mm_Vertical
J603: DFPlayermini; DFPlayer_mini_20241116
J604: 2mm_2Pin; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J701: DE9_Receptacle_MountingHoles; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_H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
MF103, MF601, MF602, MF603, MF604, MF605: U_Box_V104_General_Alarm_Device_LED_Standoff
Q201, Q202, Q203, Q204, Q205, Q206, Q207: MMBT2222A-7-F; SOT-23
Q301, Q302, Q303, Q304, Q305, Q401, Q402: BSS138; SOT-23
R101, R213, R216, R305, R307, R309, R310, R512, R711, R1002, R1009: 1R0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R102, R214, R215, R603, R1003, R1004, R1005: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R106, R107, R306, R308, R314, R317, R320, R323, R407, R408, R707, R708: DNI; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R110, R112, R202, R204, R206, R208, R210, R401, R402, R403, R404, R501, R502, R503, R509, R510, R511, R701, R702, R703, R704, R705, R706, R709, R710, R1008: 330R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R113, R114, R115, R116: 39R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R201, R203, R205, R207, R209, R217, R301, R302, R303, R311, R312, R313, R315, R316, R318, R319, R321, R322, R324, R405, R406, R409, R410, R504: 4K7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R211, R212: 5K1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R304: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV301: POT 0.375 10K; Potentiometer_Bourns_3386P_Vertical
S101, S102: SWITCH_TACTILE_SPST-NO_0.05A_24V; Switch_Tactile_THT_6x6mm
S601: SWITCH_TACTILE_12mmx12mm_SPST-NO_0.05A_24V; SW_PUSH-12mm_WithCap_Green
SW101: RotaryEncoder_Switch; RotaryEncoder_Alps_EC12E-Switch_Vertical_H20mm_MP1_MP2
SYM101: Logo_Open_Hardware_Small; OSHW-Logo2_7.3x6mm_SilkScreen
SYM102: IEC_power_polarity_symbols_barrel_jack_Center_pos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; Symbol_Barrel_Polarity_Center_Positive
T101, T102, T103: ToolingHole_Pad_1.152mm; JLC_ToolingHole_0576mm
TP100: TP+3.3V; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP101, TP104, TP105, TP106: TP_GND; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP102: Vin; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP103: +5V; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP108: U0_RX; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP109: 3v3Controller; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP201: VBus; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP202: V3; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP203: nCTS; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP204: nRST; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP205: 3V3USB; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP206: U0_TX; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP301: CIPO; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP302: +12in; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP303: SCK; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP304: COPI; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP305: SS; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP306: 5VRaw; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP401: Vcc_LCD; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP402: nINT; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP403: SCL; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP404: SDA; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP405: Vcontrast; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP501: 5VDFP; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U101: LM7805_TO220; TO-220-3_Horizontal_TabDown
U102: ESP32-WROOM-32E-N4; ESP32-WROOM-32D
U103: AMS1117-3.3; SOT-223-3_TabPin2
U301: PCF8574AT_3_518; SOIC-16W_7.5x10.3mm_P1.27mm
U302: LCD_20x4_Character-GPAD_SCH_LIB; LCD_2004A
U303: Conn_01x16; PinHeader_1x16_P2.54mm_Vertical
U501: CH340B; SOIC-16_3.9x9.9mm_P1.27mm
U701: MAX3232; SOIC-16_4.55x10.3mm_P1.27mm

Connections:
+3.3V: C117.1, C118.1, Q302.1 (G), Q303.1 (G), Q304.1 (G), Q305.1 (G), Q401.1 (G), Q402.1 (G), R101.2, R216.2, R315.2, R318.2, R322.2, R324.2, R405.2, R406.2, R603.2, R711.2, TP100.1, U103.2 (VO)
+5V: C108.1, C109.1, J102.1, R106.2, R110.2, R202.2, R204.2, R206.2, R208.2, R210.2, R310.2, R512.2, R1002.2, R1009.2, TP103.1, U101.3 (VO)
/3v3Controller: C103.1, C106.1, D103.1 (K), J104.2, R101.1, R102.2, R1003.2, R1004.2, R1005.2, TP109.1, U102.2 (VDD)
/+5esp32: +5esp32.1, C115.1, C116.1, R1002.1, U103.3 (VI)
/AlarmAudio/5VDFP: C504.1, C505.1, J603.1 (VCC), R512.1, TP501.1
/LCD And I2C Interface/Vcc_LCD: C301.1, C302.1, R301.2, R302.2, R303.2, R304.2, R306.2, R310.1, R311.2, R409.2, R410.2, RV301.3, TP401.1, U301.16 (VDD), U302.2 (VDD), U302.15 (A)
/LED_BUILTIN: J107.2, R112.2, U102.16 (GPIO13)
/RS232/3v3RS232: C703.1, C705.1, C706.1, R711.1, U701.16 (VCC)
/RS232/DCE_CTS: J701.8, R710.2
/RS232/DCE_RTS: J701.7, R709.2
/RS232/DCE_RX: J701.2, R705.2
/RS232/DCE_TX: J701.3, R706.2
/RS232/RS232_CTS: R707.1, R709.1, U701.8 (R2IN)
/RS232/RS232_RTS: R708.1, R710.1, U701.7 (T2OUT)
/RS232/RS232_RX: R706.1, U701.13 (R1IN)
/RS232/RS232_TX: R705.1, U701.14 (T1OUT)
/RT_ENC_A: J104.5, R1004.1, SW101.A, U102.5 (GPIO39_VN)
/RT_ENC_B: J104.4, R1005.1, SW101.B, U102.4 (GPIO36_VP)
/SPI Peripherial/5VRaw: C303.2, D301.2 (K), D302.2 (K), D303.2 (K), D304.2 (K), R313.2, R316.2, R319.2, R321.2, R1009.1, TP306.1
/SPI Peripherial/+12in: F401.2, J401.5, TP302.1
/SPI Peripherial/MISO: J401.6, R401.2, TP301.1
/SPI Peripherial/MOSI: J401.2, R403.2, TP304.1
/SPI Peripherial/SS: J401.1, R404.2, TP305.1
/USB_UART/3V3USB: C501.1, C502.1, R213.2, R216.1, TP205.1, U501.16 (VCC)
/USB_UART/V3: C503.1, R213.1, TP202.1, U501.4 (V3)
/nS1: J104.6, R1003.1, SW101.S1, U102.6 (GPIO34)
Busy: J106.2, R511.2, U102.26 (GPIO4)
CIPO: J106.7, Q303.2 (S), R317.2, R318.1, U102.31 (GPIO19)
COPI: Q304.2 (S), R113.1, R320.2, R322.1
CTS1: J104.9, R704.1, U102.9 (GPIO33)
ControllerRX: J106.10, R502.1, TP108.1, U102.34 (RXD0/GPIO3)
ControllerRX2: J106.3, R509.2, U102.27 (RX2/GPIO16)
ControllerTX: J106.11, R503.1, U102.35 (TXD0/GPIO1)
ControllerTX2: R116.1, R510.2
ControllerVcc: F401.1, J103.2, R107.1
GND: C101.2, C102.2, C103.2, C105.2, C106.2, C108.2, C109.2, C115.2, C116.2, C117.2, C118.2, C301.2, C302.2, C303.1, C501.2, C502.2, C503.2, C504.2, C505.2, C602.2, C704.2, C705.2, C706.2, C1100.2, D105.2, D106.1 (K), D301.1 (A), D302.1 (A), D303.1 (A), D304.1 (A), D501.1 (K), H101.1, H102.1, H103.1, H104.1, J101.2, J101.3, J104.1, J106.14, J107.1, J401.3, J501.A1 (GND), J501.A12 (GND), J501.B1 (GND), J501.B12 (GND), J501.S1 (SHIELD), J602.2, J603.7 (GND), J603.10 (GND), J701.0 (PAD), J701.5, Q201.2 (E), Q202.2 (E), Q203.2 (E), Q204.2 (E), Q205.2 (E), Q301.2 (S), R211.1, R212.1, R217.1, R305.2, R307.2, R308.1, R309.2, R504.1, RV301.1, S101.3, S101.4, S102.3, S102.4, S601.3, S601.4, SW101.C, SW101.MP1 (A), SW101.MP2 (A), SW101.S2, TP101.1, TP104.1, TP105.1, TP106.1, U101.2 (GND), U102.1 (GND), U102.15 (GND), U102.38 (GND), U102.39 (GND), U103.1 (GND), U301.8 (VSS), U302.1 (VSS), U302.7 (DB0), U302.8 (DB1), U302.9 (DB2), U302.10 (DB3), U302.17 (MH1), U302.18 (MH2), U302.19 (MH3), U302.20 (MH4), U501.1 (GND), U701.15 (GND)
GPIO0: J106.1, Q207.3 (C), S102.1, S102.2, U102.25 (GPIO0)
Light0: J104.14, R201.2, U102.14 (GPIO12)
Light1: J104.13, R203.2, U102.13 (GPIO14)
Light2: J104.12, R205.2, U102.12 (GPIO27)
Light3: J104.11, R207.2, U102.11 (GPIO26)
Light4: J104.10, R209.2, U102.10 (GPIO25)
unnamed: C101.1, F101.2, J101.1, J101.4
unnamed: D101.2 (A), F101.1
unnamed: D104.2 (A), J103.1, R107.2
unnamed: D105.1, R110.1
unnamed: D106.2 (A), R112.1
unnamed: D201.1, R202.1
unnamed: D202.1, R204.1
unnamed: D203.1, R206.1
unnamed: D204.1, R208.1
unnamed: D205.1, R210.1
unnamed: D301.3 (COM), Q302.3 (D), R313.1, R314.1, R404.1
unnamed: D302.3 (COM), Q303.3 (D), R316.1, R317.1, R401.1
unnamed: D303.3 (COM), Q304.3 (D), R319.1, R320.1, R403.1
unnamed: D304.3 (COM), Q305.3 (D), R321.1, R323.1, R402.1
unnamed: D501.2 (A), R501.2
unnamed: J106.4, R116.2, U102.28 (TX2/GPIO17)
unnamed: J106.5, R115.2, U102.29 (GPIO5)
unnamed: J106.6, R114.2, U102.30 (GPIO18)
unnamed: J106.8, U102.32 (DO_NOT_CONNECT)
unnamed: J106.13, R113.2, U102.37 (GPIO23)
unnamed: J107.3, U102.17 (SHD/SD2/GPIO9)
unnamed: J107.4, U102.18 (SWP/SD3/GPIO10)
unnamed: J107.5, U102.19 (SCS/CMD/GPIO11/U1RTS)
unnamed: J107.6, U102.20 (SCK/CLK/GPIO6/U1CTS)
unnamed: J107.7, U102.21 (SDO/SD0/GPIO7)
unnamed: J107.8, U102.22 (SDI/SD1/GPIO8)
unnamed: J501.A5 (CC1), R212.2
unnamed: J501.B5 (CC2), R211.2
unnamed: J603.16 (BUSY), R511.1
unnamed: J603.2 (RX), R510.1
unnamed: J601.2, J603.6 (SPK_1), J604.2
unnamed: J601.1, J603.8 (SPK_2), J604.1
unnamed: J603.3 (TX), R509.1
unnamed: J701.4, R707.2
unnamed: J701.6, R708.2
unnamed: Q201.1 (B), R201.1
unnamed: D201.2, Q201.3 (C)
unnamed: Q202.1 (B), R203.1
unnamed: D202.2, Q202.3 (C)
unnamed: Q203.1 (B), R205.1
unnamed: D203.2, Q203.3 (C)
unnamed: Q204.1 (B), R207.1
unnamed: D204.2, Q204.3 (C)
unnamed: Q205.1 (B), R209.1
unnamed: D205.2, Q205.3 (C)
unnamed: Q206.1 (B), R214.2
unnamed: Q206.2 (E), R215.1, U501.14 (~RTS)
unnamed: Q207.1 (B), R215.2
unnamed: Q207.2 (E), R214.1, R217.2, U501.13 (~DTR)
unnamed: Q301.3 (D), U302.16 (K)
unnamed: Q301.1 (G), R312.1
unnamed: Q401.3 (D), R407.1, R410.1, TP403.1, U301.14 (SCL)
unnamed: Q402.3 (D), R408.1, R409.1, TP404.1, U301.15 (SDA)
unnamed: R1008.2, S101.1, S101.2
unnamed: R303.1, R309.1, U301.1 (A0)
unnamed: R302.1, R307.1, U301.2 (A1)
unnamed: R301.1, R305.1, U301.3 (A2)
unnamed: U301.4 (P0), U302.4 (RS)
unnamed: U301.5 (P1), U302.5 (R/W)
unnamed: U301.6 (P2), U302.6 (E)
unnamed: R311.1, R312.2, U301.7 (P3)
unnamed: U301.9 (P4), U302.11 (DB4)
unnamed: U301.10 (P5), U302.12 (DB5)
unnamed: U301.11 (P6), U302.13 (DB6)
unnamed: U301.12 (P7), U302.14 (DB7)
unnamed: R304.1, TP402.1, U301.13 (~INT)
unnamed: R306.1, R308.2, RV301.2, TP405.1, U302.3 (VO)
unnamed: TP204.1, U501.7 (RST#)
unnamed: R503.2, TP206.1, U501.3 (RXD)
unnamed: R501.1, U501.15 (TNOW)
unnamed: R502.2, U501.2 (TXD)
unnamed: J501.A6 (D+), J501.B6 (D+), U501.5 (UD+)
unnamed: J501.A7 (D-), J501.B7 (D-), U501.6 (UD-)
unnamed: R504.2, TP203.1, U501.9 (~CTS)
unnamed: C701.1, U701.1 (C1+)
unnamed: C701.2, U701.3 (C1-)
unnamed: C702.1, U701.4 (C2+)
unnamed: C702.2, U701.5 (C2-)
unnamed: R701.2, U701.12 (R1OUT)
unnamed: R704.2, U701.9 (R2OUT)
unnamed: R702.2, U701.11 (T1IN)
unnamed: R703.2, U701.10 (T2IN)
unnamed: C703.2, U701.2 (VS+)
unnamed: C704.1, U701.6 (VS-)
RTS1: J104.8, R703.1, U102.8 (GPIO32)
RX1: J107.9, R701.1, U102.23 (GPIO15/U1RXD)
SCL: J106.12, Q401.2 (S), R406.1, R407.2, U102.36 (GPIO22)
SDA: J106.9, Q402.2 (S), R405.1, R408.2, U102.33 (GPIO21)
SPI_SCK: J401.4, Q305.2 (S), R114.1, R323.2, R324.1, R402.2, TP303.1
Switch_Mute: C602.1, J104.7, J602.1, R603.1, S601.1, S601.2, U102.7 (GPIO35)
TX1: J107.10, R702.1, U102.24 (GPIO2/U1TXD)
VBus: J102.2, J501.A4 (VBUS), J501.A9 (VBUS), J501.B4 (VBUS), J501.B9 (VBUS), R106.1, TP201.1
Vin: C102.1, C105.1, D101.1 (K), D104.1 (K), TP102.1, U101.1 (VI)
nCS: Q302.2 (S), R115.1, R314.2, R315.1
nRESET: C1100.1, D103.2 (A), J104.3, Q206.3 (C), R102.1, R1008.1, U102.3 (EN)

File PWA_REV2/BOM_PCBWAY_REV2KiCad6_250910_1400.csv:

Item #,*Designator,*Qty,Manufacturer,*Mfg Part #,Description / Value,*Package/Footprint ,Type,Your Instructions / Notes
1,+5esp32,1,ronghe,RH-5000,+5esp32,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
2,C101,1,YAGEO,CC0603JRNPO9BN390,39pF,Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,
3,"C102, C106, C109, C115, C118, C302, C502, C505, C705",9,KNSCHA,RVT47UF16V67RV0019,47uF 16V,Capacitor_SMD:CP_Elec_5x5.4,,
4,"C103, C105, C108, C116, C117, C301, C303, C501, C503, C504, C602, C701, C702, C703, C704, C706",16,YAGEO,CC0603KRX7R9BB104,100nF,Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,
5,"D101, D103, D104",3,MDD¬?Microdiode Electronics¬?,SS210,Schottky 2A,GeneralPurposeAlarmDevicePCB:D_SMB_POLARITY,,
6,D106,1,Lite-On Inc.,LTST-C171KRKT,RED 0603,LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,,
7,"D301, D302, D303, D304",4,Nexperia,"BAT54S,215",BAT54S,Package_TO_SOT_SMD:SOT-23,,
8,D501,1,Hubei KENTO Elec,KT-0603R,RED 0603,LED_SMD:LED_0603_1608Metric,,
9,"F101, F401",2,Littelfuse,0603L100SLYR,Polyfuse_Small_1A,Fuse:Fuse_0603_1608Metric,,
10,J101,1,XKB Connectivity / Tensility International Corp,DC-005-5A-2.0-SMT / 54-00164,Barrel_Jack_Switch_SMT,GeneralPurposeAlarmDevicePCB:BarrelJack_CLIFF_FC681465S_SMT_Horizontal,,
11,"J102, J103, J602",3,Amphenol ICC,68000-102HLF,0.100_2Pin,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical,,
12,J401,1,TE Connectivity,5555165-1,RJ12_6P6C_HORZ,GeneralPurposeAlarmDevicePCB:RJ12_Amphenol_54601,,
13,J501,1,Korean Hroparts Elec,TYPE-C-31-M-12,USB_C_Receptacle_USB2.0,GeneralPurposeAlarmDevicePCB:USB_C_Receptacle_HRO_TYPE-C-31-M-12,,
14,J601,1,MOLEX,530470210,1X2P 1.25 mm Header,GeneralPurposeAlarmDevicePCB:Molex_PicoBlade_53047-0210_1x02_P1.25mm_Vertical,,
15,J604,1,JST,B2B-PH-K-S(LF)(SN),2mm_2Pin,Connector_JST:JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,,
16,J701,1,Connectors Pro,https://www.amazon.com/Pc-Accessories-Connectors-Connector-2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,DE9_Receptacle_MountingHoles,Connector_Dsub:DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_Housed_MountingHolesOffset11.32mm,,
17,"Q201, Q202, Q203, Q204, Q205, Q206, Q207",7,Diodes Incorporated,MMBT2222A-7-F,MMBT2222A-7-F,Package_TO_SOT_SMD:SOT-23,,
18,"Q301, Q302, Q303, Q304, Q305, Q401, Q402",7,"Yangzhou Yangjie Electronic Technology Co., Ltd",BSS138,BSS138,Package_TO_SOT_SMD:SOT-23,,
19,"R101, R213, R216, R305, R307, R309, R310, R512, R711, R1002, R1009",11,TyoHM,RMC060315%N,1R0,Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,
20,"R102, R214, R215, R603, R1003, R1004, R1005",7,TyoHM,RMC 0603 10K F N,10K,Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,
21,"R110, R112, R202, R204, R206, R208, R210, R401, R402, R403, R404, R501, R502, R503, R509, R510, R511, R701, R702, R703, R704, R705, R706, R709, R710, R1008",26,TyoHM,RMC06033301%N,330R,Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,
22,"R113, R114, R115, R116",4,TyoHM,RMC0603391%N,39R,Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,
23,"R201, R203, R205, R207, R209, R217, R301, R302, R303, R311, R312, R313, R315, R316, R318, R319, R321, R322, R324, R405, R406, R409, R410, R504",24,TyoHM,RMC 0603 4K7 F N,4K7,Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,
24,"R211, R212",2,UNI-ROYAL(Uniroyal Elec),0603WAF5101T5E,5K1,Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,
25,R304,1,TyoHM,RMC06031K1%N,1K,Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,
26,RV301,1,BOURNS,3386P-1-103LF,POT 0.375 10K,GeneralPurposeAlarmDevicePCB:Potentiometer_Bourns_3386P_Vertical,,
27,"S101, S102",2,TE Connectivity ALCOSWITCH Switches,"TE Connectivity 1825910-7,   Dongguan Guangzhu Industrial C13828",SWITCH_TACTILE_SPST-NO_0.05A_24V,GeneralPurposeAlarmDevicePCB:Switch_Tactile_THT_6x6mm,,
28,S601,1,Omron Electronics,B3F-4055,SWITCH_TACTILE_12mmx12mm_SPST-NO_0.05A_24V,GeneralPurposeAlarmDevicePCB:SW_PUSH-12mm_WithCap_Green,,
29,SW101,1,ALPSALPINE,EC11E18244AU,RotaryEncoder_Switch,GeneralPurposeAlarmDevicePCB:RotaryEncoder_Alps_EC12E-Switch_Vertical_H20mm_MP1_MP2,,
30,TP100,1,ronghe,RH-5000,TP+3.3V,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
31,"TP101, TP104, TP105, TP106",4,ronghe,RH-5116,TP_GND,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
32,TP102,1,ronghe,RH-5000,Vin,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
33,TP103,1,ronghe,RH-5000,+5V,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
34,TP108,1,ronghe,RH-5004,U0_RX,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
35,TP109,1,ronghe,RH-5000,3v3Controller,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
36,TP201,1,ronghe,RH-5000,VBus,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
37,TP202,1,ronghe,RH-5000,V3,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
38,TP203,1,ronghe,RH-5004,nCTS,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
39,TP204,1,ronghe,RH-5004,nRST,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
40,TP205,1,ronghe,RH-5000,3V3USB,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
41,TP206,1,ronghe,RH-5004,U0_TX,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
42,TP301,1,ronghe,RH-5004,CIPO,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
43,TP302,1,ronghe,RH-5004,+12in,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
44,TP303,1,ronghe,RH-5004,SCK,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
45,TP304,1,ronghe,RH-5004,COPI,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
46,TP305,1,ronghe,RH-5004,SS,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
47,TP306,1,ronghe,RH-5000,5VRaw,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
48,TP401,1,ronghe,RH-5000,Vcc_LCD,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
49,TP402,1,ronghe,RH-5004,nINT,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
50,TP403,1,ronghe,RH-5004,SCL,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
51,TP404,1,ronghe,RH-5004,SDA,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
52,TP405,1,ronghe,RH-5000,Vcontrast,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
53,TP501,1,ronghe,RH-5000,5VDFP,TestPoint:TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded,,
54,U101,1,HANSCHIP semiconductor,LM7805CTG,LM7805_TO220,Package_TO_SOT_THT:TO-220-3_Horizontal_TabDown,,
55,U102,1,Espressif Systems,ESP32-WROOM-32E-N4,ESP32-WROOM-32E-N4,GeneralPurposeAlarmDevicePCB:ESP32-WROOM-32D,,
56,U103,1,Advanced Monolithic Systems,AMS1117-3.3,AMS1117-3.3,Package_TO_SOT_SMD:SOT-223-3_TabPin2,,
57,U301,1,NXP Semicon,PCF8574AT_3_518,PCF8574AT_3_518,Package_SO:SOIC-16W_7.5x10.3mm_P1.27mm,,
58,U303,1,XFCN,PZ254V-11-16P,Conn_01x16,Connector_PinHeader_2.54mm:PinHeader_1x16_P2.54mm_Vertical,,
59,U501,1,2Mbps 3.3V Transceiver USB 2.0 SOP-16 USB Converters ROHS,,CH340B,Package_SO:SOIC-16_3.9x9.9mm_P1.27mm,,
60,U701,1,Texas Instruments,MAX3232ID,MAX3232,Package_SO:SOIC-16_4.55x10.3mm_P1.27mm,,
,,,,,,,,

## KiCad design Krake_V1/Krake_V1.kicad_pcb

Board: 4 copper layers, 98.4 x 102.4 mm, 58 parts (8 on the bottom side), 44 nets.

Parts:
C1, C5, C6, C8: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C4, C7, C9: 47uF 16V; CP_Elec_5x5.4
C3: 39pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: D_Schottky; D_SMB
D2, D3, D4, D5, D6, D7, D8: LED_T1.75_CLEAR_RED; LED_5mm_Radial
DF_Player1: DF PLAYER
ESP1: esp32
F1: Polyfuse_Small; Fuse_0603_1608Metric
H1, H2: MountingHole_Pad_3.5mm; MountingHole_3.5mm_Pad_Via
J1: Barrel_Jack_Switch_SMT; BarrelJack_CLIFF_FC681465S_SMT_Horizontal
LS1: Speaker
Q1: BSS138; SOT-23
R1: LDR03; R_LDR_10x8.5mm_P7.6mm_Vertical
R2, R3: 10 k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R7, R21, R22: 4K7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10, R12, R20: 1R0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 1 Ohm; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14, R15, R16, R17, R18: 60 ohm; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19: 330R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23, R24: DNI; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: POT 0.375 10K; Potentiometer_Bourns_3386P_Vertical
TP1, TP2, TP4: TestPoint; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP3: nINT; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP5: Vcc_LCD; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U1: LM7805_TO220; TO-220-3_Vertical
U2: PCF8574AT_3_518; SOIC-16W_7.5x10.3mm_P1.27mm
U3: LCD_20x4_Character-GPAD_SCH_LIB; LCD_2004A

Connections:
+3.3V: DF_Player1.1 (VCC), R2.2, R3.1, R11.2
+5V: C1.1, C2.1, C6.1, C7.1, ESP1.1 (VIN), R4.1, R4.2, R19.2, R20.2, TP4.1, U1.3 (VO)
GND: C1.2, C2.2, C3.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D2.2, D3.2, D4.2, D5.2, D6.2, D7.2, D8.2, DF_Player1.7 (GND), DF_Player1.8 (SPK_2), DF_Player1.10 (GND), ESP1.2 (GND), ESP1.29 (GND), H1.1, H2.1, J1.2, J1.3, LS1.1, Q1.2 (S), R1.1, R9.2, R10.2, R12.2, R24.1, RV1.1, TP1.1, U1.2 (GND), U2.8 (VSS), U3.1 (VSS), U3.7 (DB0), U3.8 (DB1), U3.9 (DB2), U3.10 (DB3), U3.17 (MH1), U3.18 (MH2), U3.19 (MH3), U3.20 (MH4)
unnamed: D1.2 (A), F1.1
unnamed: D2.1, R13.1
unnamed: D3.1, R14.1
unnamed: D4.1, R15.1
unnamed: D5.1, R16.1
unnamed: D6.1, R17.1
unnamed: D7.1, R18.1
unnamed: D8.1, R19.1
unnamed: DF_Player1.2 (RX), ESP1.24 (TX2)
unnamed: DF_Player1.6 (SPK_1), LS1.2
unnamed: DF_Player1.3 (TX), ESP1.25 (RX2)
unnamed: ESP1.30 (3V3), R11.1
unnamed: ESP1.27 (O2), R14.2
unnamed: ESP1.26 (O4), R13.2
unnamed: ESP1.23 (O5), R18.2
unnamed: ESP1.28 (O15), R15.2
unnamed: ESP1.22 (O18), R17.2
unnamed: ESP1.21 (O19), R16.2
unnamed: ESP1.20 (O21), U2.15 (SDA)
unnamed: ESP1.17 (O22), U2.14 (SCL)
unnamed: ESP1.12 (O34), R1.2
unnamed: ESP1.13 (VN), R3.2
unnamed: ESP1.14 (VP), R2.1
unnamed: F1.2, J1.1, J1.4
unnamed: Q1.3 (D), U3.16 (K)
unnamed: Q1.1 (G), R22.1
unnamed: R7.1, R12.1, U2.1 (A0)
unnamed: R6.1, R10.1, U2.2 (A1)
unnamed: R5.1, R9.1, U2.3 (A2)
unnamed: U2.4 (P0), U3.4 (RS)
unnamed: U2.5 (P1), U3.5 (R/W)
unnamed: U2.6 (P2), U3.6 (E)
unnamed: R21.1, R22.2, U2.7 (P3)
unnamed: U2.9 (P4), U3.11 (DB4)
unnamed: U2.10 (P5), U3.12 (DB5)
unnamed: U2.11 (P6), U3.13 (DB6)
unnamed: U2.12 (P7), U3.14 (DB7)
unnamed: C8.1, C9.1, R5.2, R6.2, R7.2, R8.2, R20.1, R21.2, R23.2, RV1.3, TP5.1, U2.16 (VDD), U3.2 (VDD), U3.15 (A)
unnamed: R8.1, TP3.1, U2.13 (~INT)
unnamed: R23.1, R24.2, RV1.2, U3.3 (VO)
Vin: C4.1, C5.1, D1.1 (K), TP2.1, U1.1 (VI)

Notices in the files:
PWA_REV2/PWA_REV2.kicad_pcb:
GNU Affero General Public License v3.0
CERN Open Hardware License Version 2 - Strongly Reciprocal
